# IAR project KX2026_021_TBOX.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: HC32A4A8 XHSC HC32A4A8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __DEBUG; HC32A4A8; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../common; ..\source\3_Bsw\Midwares\FreeRTOS\Source\include; ..\source\3_Bsw\Midwares\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\drivers\cmsis\Include; ..\drivers\hc32_ll_driver\inc; ..\drivers\cmsis\Device\XHSC\hc32a4xx\Include; ..\source; ..\source\6_Library; ..\source\6_Library\SeggerRtt; ..\source\3_Bsw\Midwares\FreeRTOS\Source\cmsis_rtos; ..\source\5_Mcal\Gpio; ..\source\5_Mcal\Can; ..\source\2_Rte; ..\source\5_Mcal\Uart; ..\source\1_App\Ecall; ..\source\1_App\Hmi; ..\source\3_Bsw\CanService; ..\source\3_Bsw\GnssService; ..\source\3_Bsw\TimeService; ..\source\3_Bsw\ModemService; ..\source\3_Bsw\ModemPort; ..\source\3_Bsw\MsgIF; ..\source\3_Bsw\PowerService; ..\source\3_Bsw\OutputService; ..\source\4_System\Task; ..\source\3_Bsw\InputService; ..\source\3_Bsw\ETH\lwip_port_4xx\no_os\include; ..\source\3_Bsw\ETH\lwip-2.2.0\src\include; ..\source\3_Bsw\ETH; ..\source\3_Bsw\ETH\lwip_port_4xx\hl; ..\source\3_Bsw\ETH\lwip_port\app; ..\source\3_Bsw\ETH\lwip-2.2.0\contrib\apps\ping; ..\source\3_Bsw\ETH\stubs\Os\include; ..\source\3_Bsw\ETH\stubs\Det\include; ..\source\3_Bsw\ETH\stubs\EthTrcv\include; ..\source\3_Bsw\ETH\stubs\EthIf\include; ..\source\3_Bsw\ETH\stubs\Rte\include; ..\source\3_Bsw\ETH\terminal; ..\source\3_Bsw\ETH\EBGenerate\include; ..\source\3_Bsw\ETH\stubs; ..\drivers\Eth\include; ..\source\3_Bsw\ETH\stubs\Osr; ..\source\3_Bsw\ETH\stubs\SystickIp; ..\source\3_Bsw\ETH\stubs\EthTrcv\include; ..\source\3_Bsw\ETH\stubs\Rte\include; ..\drivers\System\include; ..\drivers\bsp\ev_hc32f4a8_lqfp176; ..\drivers\bsp\components\tca9539; ..\source\3_Bsw\ModemService
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\source\3_Bsw\Midwares\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: KX2026_021_TBOX.hex
  ILINK.IlinkOutputFile: hc32a4a8ritj.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_=1; _HC32A4A8_2M_=1
  ILINK.IlinkIcfFile: config/linker/HC32A4A8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDefines: HC32A4A8; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../common; ..\source\6_Library\SeggerRtt; ..\source\3_Bsw\ModemPort; ..\source\5_Mcal\Can
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: hc32a4a8ritj.hex
  group (top)
    ../: Readme.txt
  group cmsis
    ./: startup_hc32a4a8ritj.s
    ../../common/: system_hc32a4a8ritj.c
  group driver
    ../drivers/hc32_ll_driver/src/: hc32_hal_can.c hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_ctc.c hc32_ll_dac.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_dmc.c hc32_ll_dvp.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_ermu.c hc32_ll_eth.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_fmac.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_mau.c hc32_ll_mcan.c hc32_ll_mpu.c hc32_ll_nfc.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_ske.c hc32_ll_smc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr2.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32a4a8_ll_interrupts_share.c
  group source
    ../source/: main.c
  group source/1_App
    ../source/1_App/Ecall/: Ecall.c
    ../source/1_App/Hmi/: Hmi.c
  group source/2_Rte
    ../source/2_Rte/: Rte.c Rte.h RteSys.c RteSys.h
  group source/3_Bsw
    ../drivers/bsp/ev_hc32f4a8_lqfp176/: ev_hc32a4a8_lqfp176.c ev_hc32a4a8_lqfp176_tca9539.c
    ../drivers/bsp/components/tca9539/: tca9539.c tca9539.h
  group source/3_Bsw/CanService
    ../source/3_Bsw/CanService/: CanService.c
  group source/3_Bsw/Eth
    ../source/3_Bsw/ETH/: EthService.c
  group source/3_Bsw/Eth/lwip_api
    ../source/3_Bsw/ETH/lwip-2.2.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group source/3_Bsw/Eth/lwip_app
    ../source/3_Bsw/ETH/lwip-2.2.0/src/apps/lwiperf/: lwiperf.c
    ../source/3_Bsw/ETH/lwip_port/app/: lwiperf_udp.c
    ../source/3_Bsw/ETH/lwip-2.2.0/contrib/apps/ping/: ping.c
  group source/3_Bsw/Eth/lwip_core
    ../source/3_Bsw/ETH/lwip-2.2.0/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../source/3_Bsw/ETH/lwip-2.2.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../source/3_Bsw/ETH/lwip-2.2.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group source/3_Bsw/Eth/lwip_netif
    ../source/3_Bsw/ETH/lwip-2.2.0/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ../source/3_Bsw/ETH/lwip-2.2.0/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../source/3_Bsw/ETH/lwip-2.2.0/src/netif/: ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group source/3_Bsw/Eth/lwip_port
    ../source/3_Bsw/ETH/lwip_port_4xx/hl/: ethernetif.c
    ../source/3_Bsw/ETH/lwip_port_4xx/no_os/: sys_arch.c
  group source/3_Bsw/Eth/stubs
    ../source/3_Bsw/ETH/stubs/EthTrcv/src/: EthTrcv.c
    ../source/3_Bsw/ETH/stubs/Osr/: Osr.c
    ../source/3_Bsw/ETH/stubs/Rte/src/: SchM_Eth.c
    ../source/3_Bsw/ETH/stubs/SystickIp/: Systick_Ip.c
  group source/3_Bsw/Eth/Terminal
    ../source/3_Bsw/ETH/terminal/: Terminal.c
  group source/3_Bsw/GnssService
    ../source/3_Bsw/GnssService/: GnssService.c
  group source/3_Bsw/InputService
    ../source/3_Bsw/InputService/: InputService.c InputService_Cfg.c InputService_Cfg.h
  group source/3_Bsw/Midwares/FreeRTOS
    ../source/3_Bsw/Midwares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../source/3_Bsw/Midwares/FreeRTOS/Source/include/: FreeRTOSConfig.h
  group source/3_Bsw/Midwares/FreeRTOS/cmsis_rtos
    ../source/3_Bsw/Midwares/FreeRTOS/Source/cmsis_rtos/: cmsis_os.c
  group source/3_Bsw/Midwares/FreeRTOS/portable/ARM_CM4F
    ../source/3_Bsw/Midwares/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group source/3_Bsw/Midwares/FreeRTOS/portable/MemMang
    ../source/3_Bsw/Midwares/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group source/3_Bsw/ModemPort
    ../source/3_Bsw/ModemPort/: ModemPort.c ModemPort.h
  group source/3_Bsw/ModemService
    ../source/3_Bsw/ModemService/: ModemAudio.c ModemCall.c ModemGnss.c ModemNetwork.c ModemPlatform.c ModemPower.c ModemService.c ModemTime.c ModemTime.h
  group source/3_Bsw/MsgIF
    ../source/3_Bsw/MsgIF/: MsgIF.c MsgIF.h MsgIF_Cfg.c MsgIF_Cfg.h
  group source/3_Bsw/OutputService
    ../source/3_Bsw/OutputService/: OutputService.c OutputService.h
  group source/3_Bsw/PowerService
    ../source/3_Bsw/PowerService/: PowerService.c
  group source/3_Bsw/TimeService
    ../source/3_Bsw/TimeService/: TimeService.c TimeService.h
  group source/4_System/Task
    ../source/4_System/Task/: AppTask.c CanTask.c EcallTask.c GnssTask.c ModemTask.c MonitoringTask.c PowTask.c TaskManager.c
  group source/5_Mcal/Can
    ../source/5_Mcal/Can/: Can.c Can.h Can_Cfg.h
  group source/5_Mcal/Eth
    ../drivers/Eth/src/: Eth.c Eth_Ip.c Eth_Ip_Irq.c Eth_Ipr.c Eth_Irq.c
    ../source/3_Bsw/ETH/EBGenerate/src/: Eth_Ip_Cfg.c Eth_Ip_PBcfg.c Eth_Ipr_Cfg.c Eth_Ipr_PBcfg.c Eth_PBcfg.c
  group source/5_Mcal/Gpio
    ../source/5_Mcal/Gpio/: Gpio.c Gpio.h Gpio_Cfg.c Gpio_Cfg.h
  group source/5_Mcal/Mcu
    ../source/5_Mcal/Mcu/: Mcu.c Mcu.h Mcu_Cfg.c Mcu_Cfg.h
  group source/5_Mcal/Uart
    ../source/5_Mcal/Uart/: Uart.c Uart.h Uart_Cfg.c Uart_Cfg.h
  group source/6_Library
    ../source/6_Library/: Memory.c Memory.h Types.h
  group source/6_Library/SeggerRtt
    ../source/6_Library/SeggerRtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
