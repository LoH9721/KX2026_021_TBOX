<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\KX2026_021_TBOX.ewp</path>
    </project>
    <batchBuild />
</workspace>
